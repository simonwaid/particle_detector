v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 1930 680 1930 710 { lab=GND}
N 1930 590 1930 620 { lab=Vin1}
N 1960 560 1960 590 { lab=Vin1}
N 1930 590 1970 590 { lab=Vin1}
N 1780 670 1780 710 { lab=GND}
N 1930 360 1930 400 { lab=GND}
N 2130 410 2130 500 { lab=VM1D}
N 2130 500 2130 530 { lab=VM1D}
N 2570 620 2570 640 { lab=GND}
N 2570 590 2570 620 { lab=GND}
N 2570 440 2610 440 { lab=GND}
N 2400 500 2400 510 { lab=GND}
N 2490 440 2530 440 { lab=#net1}
N 2610 440 2650 440 { lab=GND}
N 2130 530 2130 540 { lab=VM1D}
N 2230 590 2290 590 { lab=#net2}
N 1930 190 1930 220 { lab=VDD}
N 1930 250 1930 280 { lab=VGM5}
N 1930 340 1930 360 { lab=GND}
N 2130 540 2570 540 { lab=VM1D}
N 2400 440 2490 440 { lab=#net1}
N 2570 330 2940 330 { lab=VM4D}
N 2650 440 2660 440 { lab=GND}
N 2130 290 2130 340 { lab=VM1D}
N 1970 220 1970 250 { lab=VGM5}
N 1930 250 1970 250 { lab=VGM5}
N 2280 240 2280 270 { lab=VDD}
N 2280 210 2280 240 { lab=VDD}
N 2280 300 2280 320 { lab=VGM8}
N 2280 380 2280 430 { lab=GND}
N 2280 300 2320 300 { lab=VGM8}
N 2320 270 2320 300 { lab=VGM8}
N 2280 190 2280 210 { lab=VDD}
N 2280 110 2280 130 { lab=VDD}
N 2450 210 2450 270 { lab=VGM8}
N 2450 130 2450 150 { lab=VDD}
N 2570 540 2570 560 { lab=VM1D}
N 2570 470 2570 490 { lab=VM1D}
N 2570 490 2570 540 { lab=VM1D}
N 2280 130 2280 190 { lab=VDD}
N 2980 640 2980 660 { lab=#net3}
N 2960 120 2980 120 { lab=#net4}
N 2960 120 2960 150 { lab=#net4}
N 2980 90 2980 120 { lab=#net4}
N 2980 180 2980 300 { lab=VM2D}
N 2980 330 3090 330 { lab=GND}
N 3090 330 3090 360 { lab=GND}
N 1970 220 2090 220 { lab=VGM5}
N 2130 250 2130 290 { lab=VM1D}
N 2130 190 2130 220 { lab=VDD}
N 2130 340 2130 410 { lab=VM1D}
N 2570 330 2570 410 { lab=VM4D}
N 2570 160 2570 200 { lab=VDD}
N 2980 580 3080 580 { lab=VM2S}
N 2880 580 2980 580 { lab=VM2S}
N 2510 590 2510 690 { lab=VM1G}
N 1970 590 2000 590 { lab=Vin1}
N 2070 590 2230 590 { lab=#net2}
N 2060 590 2070 590 { lab=#net2}
N 2570 300 2570 330 { lab=VM4D}
N 3220 650 3220 660 { lab=GND}
N 3220 620 3220 650 { lab=GND}
N 3220 580 3220 590 { lab=VM2S}
N 3080 580 3220 580 { lab=VM2S}
N 2930 630 2930 660 { lab=GND}
N 2930 630 2940 630 { lab=GND}
N 3260 620 3350 620 { lab=VGM11}
N 3350 590 3350 620 { lab=VGM11}
N 3350 590 3390 590 { lab=VGM11}
N 3390 560 3390 590 { lab=VGM11}
N 3390 620 3390 650 { lab=GND}
N 3390 650 3390 660 { lab=GND}
N 3390 480 3390 500 { lab=VDD}
N 2570 200 2570 240 { lab=VDD}
N 2320 270 2450 270 { lab=VGM8}
N 2460 330 2570 330 { lab=VM4D}
N 2460 330 2460 350 { lab=VM4D}
N 2460 410 2460 440 { lab=#net1}
N 2350 590 2530 590 { lab=VM1G}
N 2870 620 2870 660 { lab=GND}
N 2790 580 2790 630 { lab=VM1G}
N 2250 680 2250 720 { lab=GND}
N 2980 360 2980 410 { lab=VM2S}
N 2980 470 2980 580 { lab=VM2S}
N 2980 420 2980 470 { lab=VM2S}
N 2980 410 2980 420 { lab=VM2S}
N 2700 690 2790 690 { lab=GND}
N 2650 630 2700 630 { lab=VM1G}
N 2510 670 2650 670 { lab=VM1G}
N 2450 270 2530 270 { lab=VGM8}
N 2570 240 2570 270 { lab=VDD}
N 2790 580 2820 580 { lab=VM1G}
N 2170 620 2250 620 { lab=#net2}
N 2170 620 2170 630 { lab=#net2}
N 2170 690 2250 690 { lab=GND}
N 2680 690 2700 690 { lab=GND}
N 2650 630 2650 670 { lab=VM1G}
N 2730 630 2790 630 { lab=VM1G}
N 2700 630 2730 630 { lab=VM1G}
N 2250 590 2250 620 { lab=#net2}
N 890 -1160 890 -1130 { lab=VDD}
N 890 -1180 890 -1160 { lab=VDD}
N 890 -1100 890 -1080 { lab=#net5}
N 890 -1080 890 -1070 { lab=#net5}
N 890 -1040 890 -1010 { lab=GND}
N 890 -1010 890 -990 { lab=GND}
N 850 -1130 850 -1040 { lab=#net6}
N 1060 -1160 1060 -1130 { lab=VDD}
N 1060 -1180 1060 -1160 { lab=VDD}
N 1060 -1100 1060 -1080 { lab=#net7}
N 1060 -1080 1060 -1070 { lab=#net7}
N 1060 -1040 1060 -1010 { lab=GND}
N 1060 -1010 1060 -990 { lab=GND}
N 1020 -1130 1020 -1040 { lab=#net5}
N 1230 -1160 1230 -1130 { lab=VDD}
N 1230 -1180 1230 -1160 { lab=VDD}
N 1230 -1100 1230 -1080 { lab=#net8}
N 1230 -1080 1230 -1070 { lab=#net8}
N 1230 -1040 1230 -1010 { lab=GND}
N 1230 -1010 1230 -990 { lab=GND}
N 1190 -1130 1190 -1040 { lab=#net7}
N 1390 -1160 1390 -1130 { lab=VDD}
N 1390 -1180 1390 -1160 { lab=VDD}
N 1390 -1100 1390 -1080 { lab=#net9}
N 1390 -1080 1390 -1070 { lab=#net9}
N 1390 -1040 1390 -1010 { lab=GND}
N 1390 -1010 1390 -990 { lab=GND}
N 1350 -1130 1350 -1040 { lab=#net10}
N 890 -1080 1020 -1080 { lab=#net5}
N 1060 -1080 1190 -1080 { lab=#net7}
C {devices/vsource.sym} 1780 640 0 0 {name=Vdd value=1.8}
C {devices/code.sym} 1840 -680 0 0 {name=TT_MODELS
only_toplevel=true
format="tcleval( @value )"
value="
*.lib \\\\$::SKYWATER_MODELS\\\\/sky130.lib.spice tt
.lib \\\\$::SKYWATER_MODELS\\\\/sky130.lib.spice.tt.red tt
"}
C {devices/vdd.sym} 1780 610 0 0 {name=l3 lab=VDD}
C {devices/gnd.sym} 1930 710 0 0 {name=l26 lab=GND}
C {devices/lab_pin.sym} 1960 560 0 0 {name=l14 sig_type=std_logic lab=Vin1}
C {devices/gnd.sym} 1930 400 0 0 {name=l1 lab=GND}
C {devices/gnd.sym} 1780 710 0 0 {name=l2 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 560 -550 0 0 {name=M4
L=0.5
W=2
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/gnd.sym} 2660 440 0 0 {name=l9 lab=GND}
C {devices/gnd.sym} 2570 640 0 0 {name=l10 lab=GND}
C {devices/vsource.sym} 2400 470 0 0 {name=Vbias2 value=1.55}
C {devices/gnd.sym} 2400 510 0 0 {name=l18 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2550 590 0 0 {name=M1
L=0.3
W=17
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/lab_wire.sym} 2570 540 2 0 {name=l31 sig_type=std_logic lab=VM1D}
C {devices/lab_wire.sym} 2570 300 2 0 {name=l32 sig_type=std_logic lab=VM4D}
C {devices/vsource.sym} 1930 650 0 0 {name=V1 value=0.9
*"DC 0.9 AC 1"}
C {sky130_fd_pr/pfet_01v8.sym} 1950 220 0 1 {name=M10
L=0.3
W=15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/isource.sym} 1930 310 0 0 {name=I0 value=0.92m}
C {devices/vdd.sym} 1930 190 0 0 {name=l6 lab=VDD}
C {devices/ngspice_get_value.sym} 2660 510 0 0 {name=r1 node="@m.xm1.msky130_fd_pr__nfet_01v8_lvt[gm]"
descr="M1 gm"}
C {devices/ngspice_get_value.sym} 2660 540 0 0 {name=r2 node="@m.xm1.msky130_fd_pr__nfet_01v8_lvt[gds]"
descr="M1 gds"}
C {devices/ngspice_get_value.sym} 2660 570 0 0 {name=r3 node="@m.xm1.msky130_fd_pr__nfet_01v8_lvt[cgs]"
descr="M1 cgs"}
C {devices/ngspice_get_value.sym} 2660 600 0 0 {name=r4 node="@m.xm1.msky130_fd_pr__nfet_01v8_lvt[cdg]"
descr="M1 cdg"}
C {devices/ngspice_get_value.sym} 2700 380 0 0 {name=r5 node="@m.xm4.msky130_fd_pr__nfet_01v8_lvt[gm]"
descr="M4 gm"}
C {devices/ngspice_get_value.sym} 2700 410 0 0 {name=r6 node="@m.xm4.msky130_fd_pr__nfet_01v8_lvt[gds]"
descr="M4 gds"}
C {devices/ngspice_get_value.sym} 2700 440 0 0 {name=r7 node="@m.xm4.msky130_fd_pr__nfet_01v8_lvt[cgs]"
descr="M4 cgs"}
C {devices/ngspice_get_value.sym} 2700 470 0 0 {name=r8 node="@m.xm4.msky130_fd_pr__nfet_01v8_lvt[cdg]"
descr="M4 cdg"}
C {devices/ngspice_get_value.sym} 2170 50 0 0 {name=r9 node="@m.xm6.msky130_fd_pr__pfet_01v8[gm]"
descr="M6 gm"}
C {devices/ngspice_get_value.sym} 2170 80 0 0 {name=r10 node="@m.xm6.msky130_fd_pr__pfet_01v8[gds]"
descr="M6 gds"}
C {devices/ngspice_get_value.sym} 2170 110 0 0 {name=r11 node="@m.xm6.msky130_fd_pr__pfet_01v8[cgs]"
descr="M6 cgs"}
C {devices/ngspice_get_value.sym} 2170 140 0 0 {name=r12 node="@m.xm6.msky130_fd_pr__pfet_01v8[cdg]"
descr="M6 cdg"}
C {sky130_fd_pr/pfet_01v8.sym} 2300 270 0 1 {name=M8
L=0.3
W=4
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/isource.sym} 2280 350 0 0 {name=I2 value=65u}
C {devices/gnd.sym} 2280 430 0 0 {name=l11 lab=GND}
C {devices/gnd.sym} 2280 430 0 0 {name=l13 lab=GND}
C {devices/vdd.sym} 2280 110 0 0 {name=l16 lab=VDD}
C {devices/ngspice_get_value.sym} 2700 210 0 0 {name=r13 node="@m.xm7.msky130_fd_pr__pfet_01v8[gm]"
descr="M7 gm"}
C {devices/ngspice_get_value.sym} 2700 240 0 0 {name=r14 node="@m.xm7.msky130_fd_pr__pfet_01v8[gds]"
descr="M7 gds"}
C {devices/ngspice_get_value.sym} 2700 270 0 0 {name=r15 node="@m.xm7.msky130_fd_pr__pfet_01v8[cgs]"
descr="M7 cgs"}
C {devices/ngspice_get_value.sym} 2700 300 0 0 {name=r16 node="@m.xm7.msky130_fd_pr__pfet_01v8[cdg]"
descr="M7 cdg"}
C {devices/code.sym} 1830 -370 0 0 {name=SPICE
only_toplevel=true
value="
*.options savecurrents
.option warn=1
.control
set wr_vecnames
set wr_singlescale
* Power consumption
op
* save all
* #OP#
print @m.xm1.msky130_fd_pr__nfet_01v8_lvt[gds]
print vdd#branch
print v(vm2d)
print v(vm3d)
print v(UD_M5)
wrdata 'result_op.csv' vdd#branch
ac dec 10 1 10G
meas ac dc_gain_vm2d FIND vdb(vm2d) AT=1
let bw_amp_vm2d=dc_gain_vm2d-3
meas ac dc_gain_vm3d FIND vdb(vm3d) AT=1
let bw_amp_vm3d=dc_gain_vm3d-3
meas ac bw_vm2d when vdb(vm2d)=bw_amp_vm2d
meas ac bw_vm3d when vdb(vm3d)=bw_amp_vm3d
*MEAS AC phasem FIND vp(vm2d) WHEN vdb(vm2d)=0
* wrdata 'result_ac.csv' dc_gain bw
* plot vdb(vm2D) log
*
*print WM3D
run
reset
save @m.xm1.msky130_fd_pr__nfet_01v8_lvt[gds]
save @m.xm1.msky130_fd_pr__nfet_01v8_lvt[gm]
save @m.xm1.msky130_fd_pr__nfet_01v8_lvt[cgs]
save @m.xm1.msky130_fd_pr__nfet_01v8_lvt[cdg]
save @m.xm2.msky130_fd_pr__nfet_01v8_lvt[gm]
save @m.xm2.msky130_fd_pr__nfet_01v8_lvt[gds]
save @m.xm2.msky130_fd_pr__nfet_01v8_lvt[cgs]
save @m.xm2.msky130_fd_pr__nfet_01v8_lvt[cdg]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[gm]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[gds]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[cgs]
save @m.xm4.msky130_fd_pr__nfet_01v8_lvt[cdg]
save @m.xm11.msky130_fd_pr__nfet_01v8_lvt[gm]
save @m.xm11.msky130_fd_pr__nfet_01v8_lvt[gds]
save @m.xm11.msky130_fd_pr__nfet_01v8_lvt[cgs]
save @m.xm11.msky130_fd_pr__nfet_01v8_lvt[cdg]
save @m.xm6.msky130_fd_pr__pfet_01v8[gm]
save @m.xm6.msky130_fd_pr__pfet_01v8[gds]
save @m.xm6.msky130_fd_pr__pfet_01v8[cgs]
save @m.xm6.msky130_fd_pr__pfet_01v8[cdg]
save @m.xm7.msky130_fd_pr__pfet_01v8[gm]
save @m.xm7.msky130_fd_pr__pfet_01v8[gds]
save @m.xm7.msky130_fd_pr__pfet_01v8[cgs]
save @m.xm7.msky130_fd_pr__pfet_01v8[cdg]
save v(vm2s)
save v(vm1g)
save v(vm1d)
save v(vm2d)
save v(vm3d)
save v(vm4d)
save v(vgm8)
save v(vdm8)
save v(vgm5)
save v(vgm11)
*save v(vfb)
save i(vm2s)
op
write shahdoost_optim3_manual.raw
run
reset
noise v(vm1d) I1 dec 100 1 10G
print all
setplot noise1
write noise_question1.raw
setplot noise2
write noise_question2.raw
run
reset
ac dec 10 1 1T
plot vdb(vm1d) vdb(vm4d) vdb(vm1g) 
plot vdb(vm2d) vdb(vm2s) 
*vdb(vfb)
plot phase(vm1d)/pi*180 phase(vm4d)/pi*180 phase(vm1g)/pi*180
plot phase(vm2d)/pi*180 phase(vm2s)/pi*180 phase(vfb)/pi*180
run
reset
tran 1ps 10ns
plot v(vm1g) v(vm2d)
run
.endc 
"}
C {devices/ngspice_get_value.sym} 2570 370 0 0 {name=r17 node="v(vm4d)"
descr="v(vm4d)"}
C {devices/ngspice_get_value.sym} 2570 520 0 0 {name=r18 node="v(vm1d)"
descr="v(vm1d)"}
C {devices/lab_wire.sym} 2360 270 2 0 {name=l17 sig_type=std_logic lab=VGM8}
C {devices/ngspice_get_value.sym} 2400 270 0 0 {name=r19 node="v(vgm8)"
descr="v(vgm8)"}
C {sky130_fd_pr/cap_mim_m3_1.sym} 2450 180 0 0 {name=C4 model=cap_mim_m3_1 W=10 L=10 MF=1 spiceprefix=X}
C {devices/vdd.sym} 2450 130 0 0 {name=l19 lab=VDD}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 2960 330 0 0 {name=M2
L=0.4
W=5
nf=1 
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/vdd.sym} 890 -1180 0 0 {name=l4 lab=VDD}
C {devices/gnd.sym} 890 -990 0 0 {name=l15 lab=GND}
C {sky130_fd_pr/res_high_po_0p35.sym} 2980 150 0 0 {name=R2
W=0.35
L=3
model=res_high_po_0p35
spiceprefix=X
mult=5}
C {devices/gnd.sym} 3090 360 0 0 {name=l20 lab=GND}
C {devices/lab_wire.sym} 2980 260 2 0 {name=l21 sig_type=std_logic lab=VM2D}
C {devices/lab_wire.sym} 2980 550 2 0 {name=l22 sig_type=std_logic lab=VM2S}
C {devices/ngspice_get_value.sym} 2980 530 0 0 {name=r21 node="v(vm2s)"
descr="v(vm2s)"}
C {devices/ngspice_get_value.sym} 2980 240 0 0 {name=r22 node="v(vm2d)"
descr="v(vm2d)"}
C {devices/ngspice_get_value.sym} 3070 230 0 0 {name=r23 node="@m.xm2.msky130_fd_pr__nfet_01v8_lvt[gm]"
descr="M2 gm"}
C {devices/ngspice_get_value.sym} 3070 260 0 0 {name=r24 node="@m.xm2.msky130_fd_pr__nfet_01v8_lvt[gds]"
descr="M2 gds"}
C {devices/ngspice_get_value.sym} 3070 290 0 0 {name=r25 node="@m.xm2.msky130_fd_pr__nfet_01v8_lvt[cgs]"
descr="M2 cgs"}
C {devices/ngspice_get_value.sym} 3070 320 0 0 {name=r26 node="@m.xm2.msky130_fd_pr__nfet_01v8_lvt[cdg]"
descr="M2 cdg"}
C {sky130_fd_pr/pfet_01v8.sym} 560 -670 0 0 {name=M6
L=0.3
W=15
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 2130 190 0 0 {name=l7 lab=VDD}
C {devices/lab_wire.sym} 2000 220 2 0 {name=l23 sig_type=std_logic lab=VGM5}
C {devices/ngspice_get_value.sym} 2010 220 0 0 {name=r27 node="v(vgm5)"
descr="v(vgm5)"}
C {devices/vdd.sym} 2570 160 0 0 {name=l5 lab=VDD}
C {devices/gnd.sym} 2930 660 0 0 {name=l25 lab=GND}
C {devices/res.sym} 2030 590 1 0 {name=R4
value=1e6
footprint=1206
device=resistor
m=1}
C {devices/lab_pin.sym} 2510 690 0 0 {name=l28 sig_type=std_logic lab=VM1G}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 870 -1040 0 0 {name=M11
L=0.150
W=0.74
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 3370 620 0 0 {name=M12
L=0.3
W=5
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {devices/isource.sym} 3390 530 0 0 {name=I1 value=1m}
C {devices/vdd.sym} 3390 480 0 0 {name=l8 lab=VDD}
C {devices/gnd.sym} 3220 660 0 0 {name=l12 lab=GND}
C {devices/gnd.sym} 3390 660 0 0 {name=l24 lab=GND}
C {devices/lab_wire.sym} 3270 620 2 0 {name=l29 sig_type=std_logic lab=VGM11}
C {devices/ngspice_get_value.sym} 3270 620 0 0 {name=r20 node="v(vgm11)"
descr="v(vgm11)"}
C {devices/ngspice_get_value.sym} 3210 480 0 0 {name=r28 node="@m.xm11.msky130_fd_pr__nfet_01v8_lvt[gm]"
descr="M11 gm"}
C {devices/ngspice_get_value.sym} 3210 510 0 0 {name=r29 node="@m.xm11.msky130_fd_pr__nfet_01v8_lvt[gds]"
descr="M11 gds"}
C {devices/ngspice_get_value.sym} 3210 540 0 0 {name=r30 node="@m.xm11.msky130_fd_pr__nfet_01v8_lvt[cgs]"
descr="M11 cgs"}
C {devices/ngspice_get_value.sym} 3210 570 0 0 {name=r31 node="@m.xm11.msky130_fd_pr__nfet_01v8_lvt[cdg]"
descr="M11 cdg"}
C {devices/res.sym} 2320 590 1 0 {name=R1
value=100
footprint=1206
device=resistor
m=1}
C {devices/gnd.sym} 2870 660 0 0 {name=l33 lab=GND}
C {devices/gnd.sym} 2790 690 0 0 {name=l27 lab=GND}
C {devices/gnd.sym} 2250 720 0 0 {name=l35 lab=GND}
C {devices/isource.sym} 2250 650 0 0 {name=I3 value="DC 0 AC 1"}
C {devices/ngspice_get_value.sym} 2410 590 0 0 {name=r32 node="v(vm1g)"
descr="v(vm1g)"}
C {sky130_fd_pr/pfet_01v8.sym} 870 -1130 0 0 {name=M3
L=0.150
W=1.12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/gnd.sym} 2570 730 0 0 {name=l34 lab=GND}
C {devices/capa.sym} 2980 610 0 0 {name=C1
m=1
value=10p
footprint=1206
device="ceramic capacitor"}
C {devices/capa.sym} 2850 580 1 0 {name=C2
m=1
value=310f
footprint=1206
device="ceramic capacitor"}
C {devices/vdd.sym} 1060 -1180 0 0 {name=l30 lab=VDD}
C {devices/gnd.sym} 1060 -990 0 0 {name=l36 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1040 -1040 0 0 {name=M5
L=0.150
W=0.74
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1040 -1130 0 0 {name=M7
L=0.150
W=1.12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1230 -1180 0 0 {name=l37 lab=VDD}
C {devices/gnd.sym} 1230 -990 0 0 {name=l38 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1210 -1040 0 0 {name=M9
L=0.150
W=0.74
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1210 -1130 0 0 {name=M13
L=0.150
W=1.12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/vdd.sym} 1390 -1180 0 0 {name=l39 lab=VDD}
C {devices/gnd.sym} 1390 -990 0 0 {name=l40 lab=GND}
C {sky130_fd_pr/nfet_01v8_lvt.sym} 1370 -1040 0 0 {name=M14
L=0.150
W=0.74
nf=1
mult=5
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8.sym} 1370 -1130 0 0 {name=M15
L=0.150
W=1.12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
