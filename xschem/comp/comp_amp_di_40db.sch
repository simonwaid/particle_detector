v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 300 810 360 810 { lab=VN}
N 300 790 490 790 { lab=OutN1_di}
N 300 770 490 770 { lab=OutP1_di}
N -60 600 -60 620 { lab=VP}
N 310 970 370 970 { lab=VN}
N 370 970 370 990 { lab=VN}
N -110 930 10 930 { lab=Bias1}
N -60 620 -60 650 { lab=VP}
N 310 950 330 950 { lab=cmm_out_di}
N 330 870 330 950 { lab=cmm_out_di}
N -100 870 330 870 { lab=cmm_out_di}
N 10 1050 450 1050 { lab=OutN1_di}
N 450 790 450 1050 { lab=OutN1_di}
N 470 770 470 1070 { lab=OutP1_di}
N -20 1070 470 1070 { lab=OutP1_di}
N -10 1050 10 1050 { lab=OutN1_di}
N -30 1070 -20 1070 { lab=OutP1_di}
N -60 650 -60 680 { lab=VP}
N -100 680 -100 870 { lab=cmm_out_di}
N -10 990 10 990 { lab=OutN1_di}
N -10 990 -10 1050 { lab=OutN1_di}
N -20 970 10 970 { lab=OutP1_di}
N -30 970 -20 970 { lab=OutP1_di}
N -30 970 -30 1070 { lab=OutP1_di}
N -50 1010 10 1010 { lab=V_ref}
N -50 950 0 950 { lab=V_ref}
N 0 950 10 950 { lab=V_ref}
N -50 950 -50 1010 { lab=V_ref}
N -110 980 -50 980 { lab=V_ref}
N 490 790 520 790 { lab=OutN1_di}
N 1010 960 1070 960 { lab=VN}
N 1070 960 1070 980 { lab=VN}
N 590 920 710 920 { lab=Bias2}
N 1010 940 1030 940 { lab=#net1}
N 1030 860 1030 940 { lab=#net1}
N 600 860 1030 860 { lab=#net1}
N 710 1040 1110 1040 { lab=#net2}
N 680 1060 1130 1060 { lab=#net3}
N 690 1040 710 1040 { lab=#net2}
N 670 1060 680 1060 { lab=#net3}
N 690 980 710 980 { lab=#net2}
N 690 980 690 1040 { lab=#net2}
N 680 960 710 960 { lab=#net3}
N 670 960 680 960 { lab=#net3}
N 670 960 670 1060 { lab=#net3}
N 650 1000 710 1000 { lab=V_ref}
N 650 940 700 940 { lab=V_ref}
N 700 940 710 940 { lab=V_ref}
N 650 940 650 1000 { lab=V_ref}
N 510 970 650 970 { lab=V_ref}
N 630 600 630 620 { lab=VP}
N 630 620 630 650 { lab=VP}
N 630 650 630 680 { lab=VP}
N 590 680 590 860 { lab=#net1}
N 590 860 600 860 { lab=#net1}
N 1000 810 1060 810 { lab=VN}
N 1000 790 1110 790 { lab=#net2}
N 1110 790 1110 1040 { lab=#net2}
N 1000 770 1130 770 { lab=#net3}
N 1130 770 1130 1060 { lab=#net3}
N 510 750 700 750 { lab=OutP1_di}
N 510 750 510 770 { lab=OutP1_di}
N 490 770 510 770 { lab=OutP1_di}
N 520 790 530 790 { lab=OutN1_di}
N 530 770 530 790 { lab=OutN1_di}
N 530 770 700 770 { lab=OutN1_di}
N 630 790 700 790 { lab=#net4}
N 630 710 630 790 { lab=#net4}
N 510 970 510 1060 { lab=V_ref}
N -60 830 0 830 { lab=#net5}
N -60 710 -60 830 { lab=#net5}
N -170 770 0 770 { lab=In_p}
N -170 750 0 750 { lab=In_n}
N -170 790 0 790 { lab=In_ref_n}
N -170 810 0 810 { lab=In_ref_p}
N 510 1060 510 1100 { lab=V_ref}
N -50 1100 510 1100 { lab=V_ref}
N -50 1010 -50 1100 { lab=V_ref}
N -170 1130 370 1130 { lab=VN}
N 370 990 370 1130 { lab=VN}
N 310 930 350 930 { lab=VP}
N 350 750 350 930 { lab=VP}
N 360 810 370 810 { lab=VN}
N 370 810 370 970 { lab=VN}
N -170 580 350 580 { lab=VP}
N 350 580 350 750 { lab=VP}
N -60 580 -60 600 { lab=VP}
N 350 580 630 580 { lab=VP}
N 630 580 630 600 { lab=VP}
N 1000 750 1050 750 { lab=VP}
N 1050 590 1050 750 { lab=VP}
N 1050 580 1050 590 { lab=VP}
N 630 580 1050 580 { lab=VP}
N 1010 920 1050 920 { lab=VP}
N 1060 810 1070 810 { lab=VN}
N 1070 810 1070 960 { lab=VN}
N 370 1130 1070 1130 { lab=VN}
N 1070 980 1070 1130 { lab=VN}
N 1130 770 1160 770 { lab=#net3}
N 1110 790 1160 790 { lab=#net2}
N 300 750 350 750 { lab=VP}
N 1050 750 1050 920 { lab=VP}
N 1660 960 1720 960 { lab=VN}
N 1720 960 1720 980 { lab=VN}
N 1240 920 1360 920 { lab=Bias3}
N 1660 940 1680 940 { lab=#net6}
N 1680 860 1680 940 { lab=#net6}
N 1250 860 1680 860 { lab=#net6}
N 1360 1040 1760 1040 { lab=#net7}
N 1330 1060 1780 1060 { lab=#net8}
N 1340 1040 1360 1040 { lab=#net7}
N 1320 1060 1330 1060 { lab=#net8}
N 1340 980 1360 980 { lab=#net7}
N 1340 980 1340 1040 { lab=#net7}
N 1330 960 1360 960 { lab=#net8}
N 1320 960 1330 960 { lab=#net8}
N 1320 960 1320 1060 { lab=#net8}
N 1300 1000 1360 1000 { lab=V_ref}
N 1300 940 1350 940 { lab=V_ref}
N 1350 940 1360 940 { lab=V_ref}
N 1300 940 1300 1000 { lab=V_ref}
N 1160 970 1300 970 { lab=V_ref}
N 1280 600 1280 620 { lab=VP}
N 1280 620 1280 650 { lab=VP}
N 1280 650 1280 680 { lab=VP}
N 1240 680 1240 860 { lab=#net6}
N 1240 860 1250 860 { lab=#net6}
N 1650 810 1710 810 { lab=VN}
N 1650 790 1760 790 { lab=#net7}
N 1760 790 1760 1040 { lab=#net7}
N 1650 770 1780 770 { lab=#net8}
N 1780 770 1780 1060 { lab=#net8}
N 1160 750 1350 750 { lab=#net3}
N 1160 750 1160 770 { lab=#net3}
N 1170 790 1180 790 { lab=#net2}
N 1180 770 1180 790 { lab=#net2}
N 1180 770 1350 770 { lab=#net2}
N 1280 790 1350 790 { lab=#net9}
N 1280 710 1280 790 { lab=#net9}
N 1160 970 1160 1060 { lab=V_ref}
N 1160 1060 1160 1100 { lab=V_ref}
N 1280 580 1280 600 { lab=VP}
N 1650 750 1700 750 { lab=VP}
N 1700 590 1700 750 { lab=VP}
N 1700 580 1700 590 { lab=VP}
N 1280 580 1700 580 { lab=VP}
N 1660 920 1700 920 { lab=VP}
N 1710 810 1720 810 { lab=VN}
N 1720 810 1720 960 { lab=VN}
N 1720 980 1720 1130 { lab=VN}
N 1780 770 1810 770 { lab=#net8}
N 1760 790 1810 790 { lab=#net7}
N 1700 750 1700 920 { lab=VP}
N 1160 790 1170 790 { lab=#net2}
N 510 1100 1160 1100 { lab=V_ref}
N 1070 1130 1720 1130 { lab=VN}
N 2310 960 2370 960 { lab=VN}
N 2370 960 2370 980 { lab=VN}
N 1890 920 2010 920 { lab=Bias4}
N 2310 940 2330 940 { lab=#net10}
N 2330 860 2330 940 { lab=#net10}
N 1900 860 2330 860 { lab=#net10}
N 2010 1040 2410 1040 { lab=Out_n}
N 1980 1060 2430 1060 { lab=Out_p}
N 1990 1040 2010 1040 { lab=Out_n}
N 1970 1060 1980 1060 { lab=Out_p}
N 1990 980 2010 980 { lab=Out_n}
N 1990 980 1990 1040 { lab=Out_n}
N 1980 960 2010 960 { lab=Out_p}
N 1970 960 1980 960 { lab=Out_p}
N 1970 960 1970 1060 { lab=Out_p}
N 1950 1000 2010 1000 { lab=V_ref}
N 1950 940 2000 940 { lab=V_ref}
N 2000 940 2010 940 { lab=V_ref}
N 1950 940 1950 1000 { lab=V_ref}
N 1810 970 1950 970 { lab=V_ref}
N 1930 600 1930 620 { lab=VP}
N 1930 620 1930 650 { lab=VP}
N 1930 650 1930 680 { lab=VP}
N 1890 680 1890 860 { lab=#net10}
N 1890 860 1900 860 { lab=#net10}
N 2300 810 2360 810 { lab=VN}
N 2300 790 2410 790 { lab=Out_n}
N 2410 790 2410 1040 { lab=Out_n}
N 2300 770 2430 770 { lab=Out_p}
N 2430 770 2430 1060 { lab=Out_p}
N 1810 750 2000 750 { lab=#net8}
N 1810 750 1810 770 { lab=#net8}
N 1820 790 1830 790 { lab=#net7}
N 1830 770 1830 790 { lab=#net7}
N 1830 770 2000 770 { lab=#net7}
N 1930 790 2000 790 { lab=#net11}
N 1930 710 1930 790 { lab=#net11}
N 1810 970 1810 1060 { lab=V_ref}
N 1810 1060 1810 1100 { lab=V_ref}
N 1930 580 1930 600 { lab=VP}
N 2300 750 2350 750 { lab=VP}
N 2350 590 2350 750 { lab=VP}
N 2350 580 2350 590 { lab=VP}
N 1930 580 2350 580 { lab=VP}
N 2310 920 2350 920 { lab=VP}
N 2360 810 2370 810 { lab=VN}
N 2370 810 2370 960 { lab=VN}
N 2370 980 2370 1130 { lab=VN}
N 2430 770 2460 770 { lab=Out_p}
N 2410 790 2460 790 { lab=Out_n}
N 2350 750 2350 920 { lab=VP}
N 1810 790 1820 790 { lab=#net7}
N 1160 1100 1810 1100 { lab=V_ref}
N 1720 1130 2370 1130 { lab=VN}
N 1050 580 1280 580 { lab=VP}
N 1700 580 1930 580 { lab=VP}
C {comp/comp_adv3_di.sym} 150 790 0 0 {name=x4}
C {devices/lab_wire.sym} 380 770 0 1 {name=l32 sig_type=std_logic lab=OutP1_di}
C {devices/lab_wire.sym} 380 790 0 1 {name=l33 sig_type=std_logic lab=OutN1_di}
C {devices/ngspice_get_value.sym} 440 710 0 0 {name=r6 node="v(OutP1)"
descr="v(OutP1)"}
C {devices/ngspice_get_value.sym} 450 730 0 0 {name=r7 node="v(OutN1)"
descr="v(OutN1)"}
C {cmm_sense/cmm_sense5.sym} 160 970 0 0 {name=x5}
C {devices/lab_wire.sym} 90 870 0 1 {name=l38 sig_type=std_logic lab=cmm_out_di}
C {devices/ngspice_get_value.sym} 90 900 0 0 {name=r8 node="v(cmm_out)"
descr="v(cmm_out)"}
C {comp/comp_adv3.sym} 850 780 0 0 {name=xcmp6}
C {cmm_sense/cmm_sense5.sym} 860 960 0 0 {name=x7}
C {devices/ngspice_get_value.sym} 790 890 0 0 {name=r9 node="v(cmm_out)"
descr="v(cmm_out)"}
C {sky130_fd_pr/pfet_01v8_lvt.sym} -80 680 0 0 {name=M4
L=0.5
W=2
nf=1
mult=16
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {devices/ipin.sym} -170 750 0 0 {name=p1 lab=In_n}
C {devices/iopin.sym} -170 580 0 1 {name=p2 lab=VP}
C {devices/opin.sym} 2460 770 0 0 {name=p3 lab=Out_p}
C {devices/ipin.sym} -170 770 0 0 {name=p4 lab=In_p}
C {devices/ipin.sym} -170 790 0 0 {name=p5 lab=In_ref_n}
C {devices/ipin.sym} -170 810 0 0 {name=p6 lab=In_ref_p}
C {devices/ipin.sym} -110 930 0 0 {name=p7 lab=Bias1}
C {devices/ipin.sym} -110 980 0 0 {name=p8 lab=V_ref}
C {devices/ipin.sym} 590 920 0 0 {name=p9 lab=Bias2}
C {devices/iopin.sym} -170 1130 0 1 {name=p10 lab=VN}
C {devices/opin.sym} 2460 790 0 0 {name=p11 lab=Out_n}
C {comp/comp_adv3.sym} 1500 780 0 0 {name=xcmp1}
C {cmm_sense/cmm_sense5.sym} 1510 960 0 0 {name=x2}
C {devices/ngspice_get_value.sym} 1440 890 0 0 {name=r1 node="v(cmm_out)"
descr="v(cmm_out)"}
C {devices/ipin.sym} 1240 920 0 0 {name=p12 lab=Bias3}
C {comp/comp_adv3.sym} 2150 780 0 0 {name=xcmp2}
C {cmm_sense/cmm_sense5.sym} 2160 960 0 0 {name=x3}
C {devices/ngspice_get_value.sym} 2090 890 0 0 {name=r2 node="v(cmm_out)"
descr="v(cmm_out)"}
C {devices/ipin.sym} 1890 920 0 0 {name=p13 lab=Bias4}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 610 680 0 0 {name=M1
L=0.5
W=2
nf=1
mult=16
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1260 680 0 0 {name=M2
L=0.5
W=2
nf=1
mult=16
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
C {sky130_fd_pr/pfet_01v8_lvt.sym} 1910 680 0 0 {name=M3
L=0.5
W=2
nf=1
mult=16
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8_lvt
spiceprefix=X
}
